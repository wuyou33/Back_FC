# Keil uVision project F407_FC.uvprojx, settings and files
target OLD-X FC 2.0 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4,__CC_ARM
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\DSP_LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./applications/: include.h scheduler.c init.c parameter.c fly_mode.c main.c stm32f4xx_it.c
  group Drivers
    ./drivers/: pwm_out.c i2c_soft.c led.c time.c
    ./applications/: flash.c iic_hml.c spi.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Math&Fushion
    ./applications/: imu.c alt_fushion.c anotc_baro_ctrl.c mymath.c filter.c FastMath.c quar.c rt_nonfinite.c rtGetInf.c rtGetNaN.c baro_ekf_oldx.lib kf_oldx.lib ukf_bmp.c
  group Control
    ./applications/: ctrl.c height_ctrl.c pos_ctrl.c eso_oldx.lib
  group Communication
    ./drivers/: usart.c
    ./applications/: data_transfer.c rc.c dma.c
  group Sensor
    ./drivers/: mpu6050.c ak8975.c ultrasonic.c
    ./applications/: bmp.c cycle_cal_oldx.lib
software components: CMSIS:CORE 4.3.0
